# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: NEW1-2-3-4 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\Library\LED;..\Library\OLED;..\USER;..\Library\UART2;..\Library\KEY;..\Library\DWM1000;..\Library\DWM1000\decadriver;..\Library\DWM1000\platform;..\Library\DWM1000\STM32F10x_StdPeriph_Driver;..\Library\ADC
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: startup_stm32f10x_md.s
  group USER
    ./: test.c headfile.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group Library
    ../Library/UART2/: usart2.c usart2.h
    ../Library/LED/: led.c led.h
    ../Library/KEY/: key.c key.h
    ../Library/ADC/: adc.c
  group OLED
    ../Library/OLED/: oled.c oled.h ws.h
  group DWM1000
    ../Library/DWM1000/: dwm1000.c dwm1000.h
  group platform
    ../Library/DWM1000/platform/: deca_mutex.c deca_sleep.c deca_spi.c port.c
  group decadriver
    ../Library/DWM1000/decadriver/: deca_device.c deca_params_init.c deca_range_tables.c
  group StdPeriph_Driver
    ../Library/DWM1000/STM32F10x_StdPeriph_Driver/: system_stm32f10x.c system_stm32f10x.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_exti.c stm32f10x_exti.h misc.c misc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_it.c stm32f10x_it.h stm32f10x_adc.c
